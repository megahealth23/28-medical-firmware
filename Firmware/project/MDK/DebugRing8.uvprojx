# Keil uVision project DebugRing8.uvprojx, settings and files
target Ring (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: Debug8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HRV_RECORD ZG28_V5_ENABLE CONFIG_JLINK_MONITOR_ENABLED DEBUG ARM_MATH_CM4 __FPU_PRESENT  CMSIS_DSPLIB_CM4 DFU_SUPPORT BLE_STACK_SUPPORT_REQD BOARD_PCA10056  xCONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  NRF52840_XXAA NRF_CRYPTO_MAX_INSTANCE_COUNT=1 NRF_SD_BLE_API_VERSION=6 S140 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192 BL_SETTINGS_ACCESS_ONLY NRF_DFU_SVCI_ENABLED  NRF_DFU_TRANSPORT_BLE=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\components;..\..\..\components\ble\ble_advertising;..\..\..\components\ble\ble_dtm;..\..\..\components\ble\ble_racp;..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\components\ble\ble_services\ble_bas;..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\components\ble\ble_services\ble_cscs;..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\components\ble\ble_services\ble_dfu;..\..\..\components\ble\ble_services\ble_dis;..\..\..\components\ble\ble_services\ble_gls;..\..\..\components\ble\ble_services\ble_hids;..\..\..\components\ble\ble_services\ble_hrs;..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\components\ble\ble_services\ble_hts;..\..\..\components\ble\ble_services\ble_ias;..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\components\ble\ble_services\ble_lbs;..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\components\ble\ble_services\ble_lls;..\..\..\components\ble\ble_services\ble_nus;..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\components\ble\ble_services\ble_rscs;..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\components\ble\ble_services\ble_tps;..\..\..\components\ble\common;..\..\..\components\ble\nrf_ble_gatt;..\..\..\components\ble\nrf_ble_qwr;..\..\..\components\ble\peer_manager;..\..\..\components\boards;..\..\..\components\libraries\atomic;..\..\..\components\libraries\atomic_fifo;..\..\..\components\libraries\atomic_flags;..\..\..\components\libraries\balloc;..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\components\libraries\bsp;..\..\..\components\libraries\button;..\..\..\components\libraries\cli;..\..\..\components\libraries\crc16;..\..\..\components\libraries\crc32;..\..\..\components\libraries\crypto;..\..\..\components\libraries\crypto\backend\cc310;..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\components\libraries\crypto\backend\cifra;..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\components\libraries\crypto\backend\oberon;..\..\..\components\libraries\crypto\backend\optiga;..\..\..\components\libraries\csense;..\..\..\components\libraries\csense_drv;..\..\..\components\libraries\delay;..\..\..\components\libraries\ecc;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\experimental_task_manager;..\..\..\components\libraries\fds;..\..\..\components\libraries\fstorage;..\..\..\components\libraries\gfx;..\..\..\components\libraries\gpiote;..\..\..\components\libraries\hardfault;..\..\..\components\libraries\hci;..\..\..\components\libraries\led_softblink;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\libraries\low_power_pwm;..\..\..\components\libraries\mem_manager;..\..\..\components\libraries\memobj;..\..\..\components\libraries\mpu;..\..\..\components\libraries\mutex;..\..\..\components\libraries\pwm;..\..\..\components\libraries\pwr_mgmt;..\..\..\components\libraries\queue;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\sdcard;..\..\..\components\libraries\sensorsim;..\..\..\components\libraries\slip;..\..\..\components\libraries\sortlist;..\..\..\components\libraries\spi_mngr;..\..\..\components\libraries\stack_guard;..\..\..\components\libraries\stack_info;..\..\..\components\libraries\strerror;..\..\..\components\libraries\svc;..\..\..\components\libraries\timer;..\..\..\components\libraries\twi_mngr;..\..\..\components\libraries\twi_sensor;..\..\..\components\libraries\usbd;..\..\..\components\libraries\usbd\class\audio;..\..\..\components\libraries\usbd\class\cdc;..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\components\libraries\usbd\class\hid;..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\components\libraries\usbd\class\msc;..\..\..\components\libraries\util;..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\components\nfc\ndef\generic\message;..\..\..\components\nfc\ndef\generic\record;..\..\..\components\nfc\ndef\launchapp;..\..\..\components\nfc\ndef\parser\message;..\..\..\components\nfc\ndef\parser\record;..\..\..\components\nfc\ndef\text;..\..\..\components\nfc\ndef\uri;..\..\..\components\nfc\t2t_lib;..\..\..\components\nfc\t2t_parser;..\..\..\components\nfc\t4t_lib;..\..\..\components\nfc\t4t_parser\apdu;..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\components\nfc\t4t_parser\tlv;..\..\..\components\softdevice\common;..\..\..\components\softdevice\s140\headers;..\..\..\components\softdevice\s140\headers\nrf52;..\..\..\external\fprintf;..\..\..\external\mbedtls\include;..\..\..\external\nrf_cc310\include;..\..\..\external\nrf_oberon;..\..\..\external\nrf_oberon\include;..\..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\..\external\segger_rtt;..\..\..\external\utf_converter;..\..\..\integration\nrfx;..\..\..\integration\nrfx\legacy;..\..\..\modules\nrfx;..\..\..\modules\nrfx\drivers\include;..\..\..\modules\nrfx\hal;..\..\..\modules\nrfx\mdk;..\config;..\..\..\components\libraries\svc;..\..\..\components\libraries\bootloader;..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\components\libraries\bootloader\dfu;..\..\..\components\libraries\block_dev;..\..\..\components\libraries\block_dev\empty;..\..\..\components\libraries\block_dev\qspi;..\..\..\components\libraries\block_dev\ram;..\..\..\components\libraries\block_dev\sdc;..\..\..\external\fatfs\src;..\..\..\external\fatfs\port;..\..\..\components\libraries\fifo;..\..\..\components\libraries\uart;..\..\source\services;..\..\source\acc;..\..\source\tmp;..\..\source\afe;..\..\source;..\..\source\handon_led;..\..\source\flash;..\..\..\Firmware;..\..\source\battery;..\..\source\power;..\..\..\components\libraries\pwm;..\..\source\time
  asm define: DEBUG BLE_STACK_SUPPORT_REQD BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_CRYPTO_MAX_INSTANCE_COUNT=1 NRF_SD_BLE_API_VERSION=6 S140 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DDEBUG,-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_CRYPTO_MAX_INSTANCE_COUNT=1,-DNRF_SD_BLE_API_VERSION=6,-DS140,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\components;..\..\..\components\ble\ble_advertising;..\..\..\components\ble\ble_dtm;..\..\..\components\ble\ble_racp;..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\components\ble\ble_services\ble_bas;..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\components\ble\ble_services\ble_cscs;..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\components\ble\ble_services\ble_dfu;..\..\..\components\ble\ble_services\ble_dis;..\..\..\components\ble\ble_services\ble_gls;..\..\..\components\ble\ble_services\ble_hids;..\..\..\components\ble\ble_services\ble_hrs;..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\components\ble\ble_services\ble_hts;..\..\..\components\ble\ble_services\ble_ias;..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\components\ble\ble_services\ble_lbs;..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\components\ble\ble_services\ble_lls;..\..\..\components\ble\ble_services\ble_nus;..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\components\ble\ble_services\ble_rscs;..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\components\ble\ble_services\ble_tps;..\..\..\components\ble\common;..\..\..\components\ble\nrf_ble_gatt;..\..\..\components\ble\nrf_ble_qwr;..\..\..\components\ble\peer_manager;..\..\..\components\boards;..\..\..\components\libraries\atomic;..\..\..\components\libraries\atomic_fifo;..\..\..\components\libraries\atomic_flags;..\..\..\components\libraries\balloc;..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\components\libraries\bsp;..\..\..\components\libraries\button;..\..\..\components\libraries\cli;..\..\..\components\libraries\crc16;..\..\..\components\libraries\crc32;..\..\..\components\libraries\crypto;..\..\..\components\libraries\crypto\backend\cc310;..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\components\libraries\crypto\backend\cifra;..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\components\libraries\crypto\backend\oberon;..\..\..\components\libraries\crypto\backend\optiga;..\..\..\components\libraries\csense;..\..\..\components\libraries\csense_drv;..\..\..\components\libraries\delay;..\..\..\components\libraries\ecc;..\..\..\components\libraries\experimental_section_vars;..\..\..\components\libraries\experimental_task_manager;..\..\..\components\libraries\fds;..\..\..\components\libraries\fstorage;..\..\..\components\libraries\gfx;..\..\..\components\libraries\gpiote;..\..\..\components\libraries\hardfault;..\..\..\components\libraries\hci;..\..\..\components\libraries\led_softblink;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\libraries\low_power_pwm;..\..\..\components\libraries\mem_manager;..\..\..\components\libraries\memobj;..\..\..\components\libraries\mpu;..\..\..\components\libraries\mutex;..\..\..\components\libraries\pwm;..\..\..\components\libraries\pwr_mgmt;..\..\..\components\libraries\queue;..\..\..\components\libraries\ringbuf;..\..\..\components\libraries\scheduler;..\..\..\components\libraries\sdcard;..\..\..\components\libraries\sensorsim;..\..\..\components\libraries\slip;..\..\..\components\libraries\sortlist;..\..\..\components\libraries\spi_mngr;..\..\..\components\libraries\stack_guard;..\..\..\components\libraries\stack_info;..\..\..\components\libraries\strerror;..\..\..\components\libraries\svc;..\..\..\components\libraries\timer;..\..\..\components\libraries\twi_mngr;..\..\..\components\libraries\twi_sensor;..\..\..\components\libraries\usbd;..\..\..\components\libraries\usbd\class\audio;..\..\..\components\libraries\usbd\class\cdc;..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\components\libraries\usbd\class\hid;..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\components\libraries\usbd\class\msc;..\..\..\components\libraries\util;..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\components\nfc\ndef\generic\message;..\..\..\components\nfc\ndef\generic\record;..\..\..\components\nfc\ndef\launchapp;..\..\..\components\nfc\ndef\parser\message;..\..\..\components\nfc\ndef\parser\record;..\..\..\components\nfc\ndef\text;..\..\..\components\nfc\ndef\uri;..\..\..\components\nfc\t2t_lib;..\..\..\components\nfc\t2t_parser;..\..\..\components\nfc\t4t_lib;..\..\..\components\nfc\t4t_parser\apdu;..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\components\nfc\t4t_parser\tlv;..\..\..\components\softdevice\common;..\..\..\components\softdevice\s140\headers;..\..\..\components\softdevice\s140\headers\nrf52;..\..\..\external\fprintf;..\..\..\external\mbedtls\include;..\..\..\external\nrf_cc310\include;..\..\..\external\nrf_oberon;..\..\..\external\nrf_oberon\include;..\..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\..\external\segger_rtt;..\..\..\external\utf_converter;..\..\..\integration\nrfx;..\..\..\integration\nrfx\legacy;..\..\..\modules\nrfx;..\..\..\modules\nrfx\drivers\include;..\..\..\modules\nrfx\hal;..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xda000
  memory RVCT9: RAM 0x20002f00 size 0x3c900
  memory RVCT10: RAM 0x2003fa00 size 0x600
  link misc: --diag_suppress 6330
  group JLink
    ../../source/JLink_Monitor/: JLINK_MONITOR.c JLINK_MONITOR_ISR_ARM.s
  group Application
    ../config/: sdk_config.h
    ../../: main.c svn_rev.c ring_startup.c ring_startup.h ring_ft.c tools.c
  group Services
    ../../source/services/: protocol.c ble_service.c ble_ring.c ble_aux.c ble_rawdata.c HRI.c md5.c
  group Flash
    ../../source/flash/: inner_flash.c Record.c
  group Source
    ../../source/: ring_bsp.c ring_swtimer.c list.c I2C.c system_clock.c mTask.c
  group Acc
    ../../source/acc/: ring_acc.c acc_ft.c
    ../../source/acc/BMI160/: bmi160.c
  group AFE
    ../../source/afe/: ring_afe.c afe_ft.c
    ../../source/afe/AFE4900/: afe4900.c
  group Algorithm
    ../../source/algorithm/: DataProcEHR.c DataProcSPO2.c fifo.c filter_datapre.c DataProcEHR.h DataProcSPO2.h fifo.h filter_datapre.h DataProcPTT.c DataProcPTT.h
  group Gesture
    ../../source/gesture/: mring_gesture.h mring_gesture.c
  group Temp
    ../../source/tmp/: ring_tmp.c tmp_ft.c
    ../../source/tmp/TMP117/: tmp117.c
  group Time
    ../../source/time/: ring_utc.c
  group Battery
    ../../source/battery/: battery_adc.c ring_battery.c battery_ft.c
  group Handon_led
    ../../source/handon_led/: ring_handonled.c handonled_ft.c
  group Power
    ../../source/power/: ring_power.c
  group DFU
    ../../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c
    ../../../components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_unbonded.c ble_dfu_bonded.c
  group UTF8/UTF16 converter
    ../../../external/utf_converter/: utf.c
  group nRF_BLE
    ../../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_lesc.c peer_data_storage.c peer_database.c peer_id.c security_dispatcher.c security_manager.c
    ../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_Drivers
    ../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_twi.c nrf_drv_ppi.c nrf_drv_power.c
    ../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_rng.c nrfx_uart.c nrfx_uarte.c nrfx_twi.c nrfx_twim.c nrfx_rtc.c nrfx_timer.c nrfx_ppi.c nrfx_saadc.c nrfx_power.c nrfx_usbd.c nrfx_systick.c
    ../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../modules/nrfx/hal/: nrf_nvmc.c
  group nRF_Libraries
    ../../../components/libraries/button/: app_button.c
    ../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../components/libraries/scheduler/: app_scheduler.c
    ../../../components/libraries/timer/: app_timer.c
    ../../../components/libraries/crc16/: crc16.c
    ../../../components/libraries/fds/: fds.c
    ../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../components/libraries/mem_manager/: mem_manager.c
    ../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../../components/libraries/atomic/: nrf_atomic.c
    ../../../components/libraries/balloc/: nrf_balloc.c
    ../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../components/libraries/memobj/: nrf_memobj.c
    ../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../components/libraries/queue/: nrf_queue.c
    ../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../components/libraries/strerror/: nrf_strerror.c
    ../../../components/libraries/sensorsim/: sensorsim.c
    ../../../components/libraries/crc32/: crc32.c
    ../../../components/libraries/fifo/: app_fifo.c
    ../../../components/libraries/uart/: app_uart_fifo.c
    ../../../components/libraries/low_power_pwm/: low_power_pwm.c
    ../../../components/libraries/pwm/: app_pwm.c
    ../../../modules/nrfx/drivers/src/: nrfx_wdt.c
    ../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
  group nRF_Log
    ../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group DSPlib
    ../../512lib/: arm_cortexM4lf_math.lib
  group WaveSrc
    ../../WaveSrc/: conv.c cwt.c cwtmath.c hsfft.c real.c wavefilt.c wavefunc.c wavelib.c wtmath.c conv.h cwt.h cwtmath.h hsfft.h real.h wavefilt.h wavefunc.h wavelib.h wtmath.h
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1
